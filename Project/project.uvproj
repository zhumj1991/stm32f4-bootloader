# Keil uVision project project.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\User;..\User\bsp_stm32f4xx\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Boot\include;..\Boot\include\configs;..\User\bsp_stm32f4xx;..\User\bsp_stm32f4xx\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\project.sct
  link misc: --no_remove
  group USER
    ../User/: main.c includes.h stm32f4xx_it.c stm32f4xx_conf.h
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group BSP
    ../User/bsp_stm32f4xx/: bsp.h
    ../User/bsp_stm32f4xx/src/: bsp_rtc.c bsp_uart.c bsp_iwdg.c bsp_spi_flash.c bsp_tim_pwm.c
  group CMSIS
    ../User/: system_stm32f4xx.c
  group FWLIB
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_flash.c
  group COMMON
    ../Boot/common/: command.c console.c cmd_boot.c cmd_bootm.c cmd_mem.c cmd_sf.c cmd_load.c xyzModem.c crc16.c cmd_date.c date.c
target CpuRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output
  AfterMake: CopyHex_CpuRAM.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,ARM_MATH_CM4,__CC_ARM,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\bsp;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
target ExtSRAM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: output +hex
  AfterMake: CopyHex_ExtSRAM.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x68000000 size 0x80000
  memory RVCT9: RAM 0x20000200 size 0xffe00
